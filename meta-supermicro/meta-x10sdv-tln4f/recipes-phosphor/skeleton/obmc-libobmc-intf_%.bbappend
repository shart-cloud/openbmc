FILESEXTRAPATHS:prepend:x10sdv-tln4f := "${THISDIR}/${PN}:"
